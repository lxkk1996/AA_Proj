# IAR project AA_MX.ewp, settings and files
configuration AA_MX (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407ZE ST STM32F407ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F407xx; EMPL_TARGET_STM32F4; MPU6050
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Drivers/CMSIS/Include; ..\Src\MPU6050\Motion_Driver; ../Middlewares/Third_Party/FatFs/src
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: AA_MX.hex
  ILINK.IlinkOutputFile: AA_MX.out
  ILINK.IlinkIcfFile: stm32f407xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../Src/: main.c gpio.c adc.c dma.c bsp_driver_sd.c sd_diskio.c fatfs.c fsmc.c i2c.c sdio.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Application/User/A_InitUI
    ../Src/Afile/: Load.c Menu_Func.c My_Menu.c My_SD.c My_UI.c
  group Application/User/BEEP
    ../Src/BEEP/: Music.c Warning.c
  group Application/User/BLE_Control
    ../Src/BLE_Control/: BLE_Control.c
  group Application/User/BMP_Decode
    ../Src/BMP/: BMP_Decode.c
  group Application/User/Call_Back
    ../Src/Call_Back/: Call_Back.c
  group Application/User/DC_Motion
    ../Src/DC_Motion/: DC_Control.c DC_PID.c
  group Application/User/IO_Redirect
    ../Src/IO_ Redirect/: IO_ Redirect.c
  group Application/User/Key
    ../Src/Key/: Key.c KeyBoard.c
  group Application/User/LCD
    ../Src/TFT/: BadApple.c LCD_Font.c LCD_RTS.c LCD_TFT.c
  group Application/User/LCD/LCD_Menu
    ../Src/TFT/Menu/: Menu.c
  group Application/User/MPU6050
    ../Src/MPU6050/: mpu6050.c
  group Application/User/OLED
    ../Src/OLED/: OLED.c OLED_Font.c
  group Application/User/RGB
    ../Src/RGB/: RGB_LED.c
  group Application/User/Tim_Delay
    ../Src/Tim_Delay/: Tim_Delay.c
  group Application/User/Tmperature_Control
    ../Src/Tmp_Control/: TMP_Control.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/Motion_Driver
    ../Src/MPU6050/Motion_Driver/: dmpKey.h dmpmap.h inv_mpu.c inv_mpu.h inv_mpu_dmp_motion_driver.c inv_mpu_dmp_motion_driver.h
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_sram.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_sd.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c ccsbcs.c
